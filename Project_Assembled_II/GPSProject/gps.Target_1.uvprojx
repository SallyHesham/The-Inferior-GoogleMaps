# Keil uVision project gps.Target_1.uvprojx, settings and files
target Target_1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab4_2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: __EVAL __MICROLIB
  c misc: -Wno-documentation -Wno-documentation-unknown-command -Wno-license-management -Wno-packed -Wno-parentheses-equality -Wno-reserved-id-macro -Wno-unused-macros -xc
  asm define: __EVAL __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry 0x00000000 --entry Reset_Handler --first __Vectors --info summarysizes --load_addr_map_info --summary_stderr
  group Source Group 1
    ./: main.c head.h ledColors.c distanceMarkII.c portEinit.c fpu.s distance.c led.c portFinit.c portsABinit.c lcd.c
    ./RTE/Device/TM4C123GH6PM/: startup_TM4C123.s
